Commit message: Increased Field of View of arena

File: rsc/plane.urdf (robot description, URDF)
Before this commit: robot plane, 1 links, 0 joints
Links:
- link planeLink: geometry collision box size=14 14 0.1; visual box size=14 14 0.01
